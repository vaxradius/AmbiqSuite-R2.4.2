# Keil uVision project ctimer_pwm_output.uvprojx, settings and files
target ctimer_pwm_output (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: AMA3B1KK-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.2.6
  cpu: IRAM(0x10000000,0x00060000) IROM(0x0000C000,0x000F4000) CPUTYPE("Cortex-M4") FPU2 CLOCK(48000000) ELITTLE
  output: ctimer_pwm_output
  AfterMake: fromelf --bin --output bin\ctimer_pwm_output.bin bin\ctimer_pwm_output.axf
  AfterMake: fromelf -cedrst --output bin\ctimer_pwm_output.txt bin\ctimer_pwm_output.axf
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AM_PACKAGE_BGA AM_PART_APOLLO3 AM_FREERTOS AM_DEBUG_PRINTF keil
  c include: ../../../../..;../../../../../utils;../../../../../mcu/apollo3;../../../../../CMSIS/ARM/Include;../src;../../../bsp;../../../../../CMSIS/AmbiqMicro/Include;../../../../../devices;../../../../../third_party/FreeRTOSv10.1.1/Source/include;../../../../../third_party/FreeRTOSv10.1.1/Source/portable/Keil/AMapollo2
  memory RVCT4: ROM 0xc000 size 0xf4000
  memory RVCT9: RAM 0x10000000 size 0x60000
  scatter file: .\ctimer_pwm_output.sct
  link misc: ../../../../../mcu/apollo3/hal/keil/bin/libam_hal.lib(am_hal_global.o) --keep=am_hal_global.o(.data)
  group src
    ../../../../../mcu/apollo3/hal/: am_hal_ctimer.c
    ../src/: ctimer_pwm_output_GPIO25.c pwm_task.c rtos.c
  group utils
    ../../../../../utils/: am_util_delay.c am_util_faultisr.c am_util_stdio.c am_util_debug.c
  group keil
    ../keil/: startup_keil.s
  group lib
    ../../../bsp/keil/bin/: libam_bsp.lib
    ../../../../../mcu/apollo3/hal/keil/bin/: libam_hal.lib
  group freeRTOS
    ../../../../../third_party/FreeRTOSv10.1.1/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../../../../../third_party/FreeRTOSv10.1.1/Source/portable/Keil/AMapollo2/: port.c
    ../../../../../third_party/FreeRTOSv10.1.1/Source/portable/MemMang/: heap_2.c
  group devices
    ../../../../../devices/: am_devices_button.c am_devices_led.c
